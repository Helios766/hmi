# IAR project FT_GEN_HMI_800480.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZE ST STM32F429ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40_41xxx
  ICCARM.CCIncludePath2: ..\..\User\Main; ..\..\STM32F4xx_Firmware_Library\STM32F4xx_StdPeriph_Driver\inc; ..\..\STM32F4xx_Firmware_Library\CMSIS\Device\ST\STM32F4xx\Include; ..\..\STM32F4xx_Firmware_Library\CMSIS\Include; ..\..\Hardware\FSMC_LCD; ..\..\User\MCU_Patch; ..\..\Hardware\Systick; ..\..\Hardware\SDRAM
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\FreeRTOS
  OBJCOPY.OOCOutputFile: FT_GEN_HMI_800480.hex
  ILINK.IlinkOutputFile: FT_GEN_HMI_800480.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group FatFS/Config
    ../../FatFS/: ffconf.h
  group FatFS/Source
    ../../FatFS/option/: cc936.c
    ../../FatFS/: diskio.c ff.c
  group FreeRTOS
    ../../FreeRTOS/: FreeRTOSConfig.h
  group FreeRTOS/Port
    ../../FreeRTOS/portable/MemMang/: heap_4.c
    ../../FreeRTOS/portable/IAR/: port.c portasm.s
  group FreeRTOS/Source
    ../../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Hardware
    ../../Hardware/FSMC_LCD/: bsp_lcd.c
    ../../Hardware/SDRAM/: bsp_sdram.c
    ../../Hardware/Systick/: bsp_systick.c
  group LVGL/App
    ../../LVGL/App/: font_cn_20.c font_en_26.c font_en_30.c font_en_44.c font_en_45.c font_simsun_26.c font_simsun_30.c gui.c gui_support.c icon_cut.c icon_dropdown.c icon_editbox.c icon_panel_1.c icon_panel_2.c icon_panel_3.c icon_panel_4.c icon_point.c icon_setting.c icon_warning.c
  group LVGL/Config
    ../../LVGL/: lv_conf.h
  group LVGL/Demo
    ../../LVGL/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
    ../../LVGL/demos/widgets/: lv_demo_widgets.c
  group LVGL/Port
    ../../LVGL/Ports/: lv_port_disp.c lv_port_fs.c lv_port_indev.c
  group LVGL/Source
    ../../LVGL/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../../LVGL/src/extra/libs/png/: lodepng.c lv_png.c
    ../../LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../../LVGL/src/extra/widgets/animimg/: lv_animimg.c
    ../../LVGL/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../../LVGL/src/extra/libs/bmp/: lv_bmp.c
    ../../LVGL/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../LVGL/src/extra/widgets/chart/: lv_chart.c
    ../../LVGL/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../LVGL/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../../LVGL/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../../LVGL/src/extra/: lv_extra.c
    ../../LVGL/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../../LVGL/src/extra/layouts/flex/: lv_flex.c
    ../../LVGL/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../../LVGL/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../../LVGL/src/extra/libs/freetype/: lv_freetype.c
    ../../LVGL/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c
    ../../LVGL/src/extra/layouts/grid/: lv_grid.c
    ../../LVGL/src/extra/others/gridnav/: lv_gridnav.c
    ../../LVGL/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../../LVGL/src/extra/others/ime/: lv_ime_pinyin.c
    ../../LVGL/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../LVGL/src/extra/others/imgfont/: lv_imgfont.c
    ../../LVGL/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../LVGL/src/extra/widgets/led/: lv_led.c
    ../../LVGL/src/extra/widgets/list/: lv_list.c
    ../../LVGL/src/extra/widgets/menu/: lv_menu.c
    ../../LVGL/src/extra/widgets/meter/: lv_meter.c
    ../../LVGL/src/extra/others/monkey/: lv_monkey.c
    ../../LVGL/src/extra/others/msg/: lv_msg.c
    ../../LVGL/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../LVGL/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../../LVGL/src/extra/libs/rlottie/: lv_rlottie.c
    ../../LVGL/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../../LVGL/src/extra/others/snapshot/: lv_snapshot.c
    ../../LVGL/src/extra/widgets/span/: lv_span.c
    ../../LVGL/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../LVGL/src/extra/widgets/spinner/: lv_spinner.c
    ../../LVGL/src/extra/widgets/tabview/: lv_tabview.c
    ../../LVGL/src/extra/themes/basic/: lv_theme_basic.c
    ../../LVGL/src/extra/themes/default/: lv_theme_default.c
    ../../LVGL/src/extra/themes/mono/: lv_theme_mono.c
    ../../LVGL/src/extra/widgets/tileview/: lv_tileview.c
    ../../LVGL/src/extra/widgets/win/: lv_win.c
  group Modbus
    ../../modbus_host/: modbus_host.c
  group STM32F4xx_Firmware_Library/CMSIS
    ../../STM32F4xx_Firmware_Library/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_Firmware_Library/Startup
    ../../STM32F4xx_Firmware_Library/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f429_439xx.s
  group STM32F4xx_Firmware_Library/STM32F4xx_Peripherals
    ../../STM32F4xx_Firmware_Library/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group User/Main
    ../../User/Main/: lcd_image.c lcd_test.c main.c
  group User/MCU_Patch
    ../../User/MCU_Patch/: stm32f4xx_conf.h stm32f4xx_it.c
