# Keil uVision project H7B0_V1.00.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: STM32H7B0VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00100000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00020000) XRAM2(0x38000000,0x00008000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: H7B0_V1.00 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H7B0xx
  c include: ..\..\STM32Cube_FW_H7_V1.12.0\STM32H7xx_HAL_Driver\Inc;..\..\STM32Cube_FW_H7_V1.12.0\STM32H7xx_HAL_Driver\Inc\Legacy;..\..\STM32Cube_FW_H7_V1.12.0\CMSIS\Include;..\..\STM32Cube_FW_H7_V1.12.0\CMSIS\Device\ST\STM32H7xx\Include;..\..\System\Inc;..\..\devices\bsp_dma;..\..\User\Main;..\..\devices\bsp_timer;..\..\devices\bsp_ltdc;..\..\devices\bsp_dma2d;..\..\devices\bsp_crc;..\..\devices\bsp_octqspi;..\..\devices\bsp_mpu;..\..\Peripherals\W25Qxx;..\..\Peripherals\lcd_base;..\..\User\debug_led
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x20000
  memory RVCT7: RAM 0x38000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x100000
  scatter file: .\Objects\H7B0_HMI.sct
  group Startup
    ../../System/: startup_stm32h7b0xx.s
  group CMSIS
    ../../STM32Cube_FW_H7_V1.12.0/CMSIS/Core/: system_stm32h7xx.c
  group STM32H7xx_HAL_Driver
    ../../STM32Cube_FW_H7_V1.12.0/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hash.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_dsi.c stm32h7xx_hal_ospi.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_hcd.c stm32h7xx_ll_usb.c stm32h7xx_hal_dma_ex.c
  group System
    ../../System/Src/: stm32h7xx_hal_msp.c stm32h7xx_it.c stm32h7xx_hal_timebase_tim.c
    ../../System/Inc/: stm32h7xx_hal_conf.h
  group devices
    ../../devices/bsp_usart/: bsp_usart.c
    ../../devices/bsp_timer/: bsp_timer.c
    ../../devices/bsp_ltdc/: bsp_ltdc.c
    ../../devices/bsp_dma2d/: bsp_dma2d.c
    ../../devices/bsp_dma/: bsp_dma.c
    ../../devices/bsp_spi/: bsp_spi.c
    ../../devices/bsp_octqspi/: bsp_octqspi.c
    ../../devices/bsp_crc/: bsp_crc.c
    ../../devices/bsp_mpu/: bsp_mpu.c
    ../../devices/bsp_i2c/: bsp_i2c.c
    ../../devices/bsp_gpio/: bsp_gpio.c
  group Peripherals
    ../../Peripherals/W25Qxx/: OSPI_W25Qxx.c
    ../../Peripherals/lcd_base/: lcd_base.c
  group User
    ../../User/Main/: main.c
    ../../User/debug_led/: debug_led.c
  group README
    ../../: README.md
