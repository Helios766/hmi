
unsigned char jtwb[128]="收款退款交易查询终端管理";	//每个中文字符实际由两个字节组成, 对应GBK等编码

unsigned char pBits[512];

/*
    功能：字符串显示
    text：字符串
    （x，y）：显示的起始坐标
*/
void show_char(unsigned char *text,unsigned int x,unsigned int y)
{
	while(*text!='\0')//判断是否是结尾
	{
		if(*text<0x80){  //ASCII 码 *text是ASCII码
			ASCII_GetData(*text, ASCII_8X16_A, pBits);	//示例, 按实际函数名进行修改
			DisZK_DZ_W(x,y,8,16, BLACK, WHITE,pBits,1);  //显示8X16点ASCII函数
			x=x+8;
		}else{  //汉字编码*text是汉字编码的高位，*(text+1)是汉字编码的低位
			gt_16_GetData(*text, *(text+1),pBits);	//示例, 按实际函数名进行修改
			DisZK_DZ_W(x,y,16,16, BLACK, WHITE,pBits,1);  //显示汉字
			x=x+16;
			text++;
		}
		text++;
	}
}

void main()
{
	unsigned char Data_buf[512];
	show_char(jtwb,0,0);


	#if 0	//汉字字符串
	unsigned short arr[3] = {0xb0a1, 0xb0a2, 0xb0a3};	//对应中文编码 , "啊": 0xb0a1 ...
	for(i=0; i<sizeof(arr), i++) {
		gt_24_data(arr[i]>>16, arr[i]&0xff, Data_buf);
		DisZK_DZ_W(j, 0, 24, 24, BLACK, WHITE, Data_buf,1);	//显示函数
		j += 24;
	}
	#endif
}


char* itoa(int num,char* str,int radix)
{
    char index[]="0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ";//索引表
    unsigned unum;//存放要转换的整数的绝对值,转换的整数可能是负数
    int i=0,j,k;//i用来指示设置字符串相应位，转换之后i其实就是字符串的长度；转换后顺序是逆序的，有正负的情况，k用来指示调整顺序的开始位置;j用来指示调整顺序时的交换。

    //获取要转换的整数的绝对值
    if(radix==10&&num<0)//要转换成十进制数并且是负数
    {
        unum=(unsigned)-num;//将num的绝对值赋给unum
        str[i++]='-';//在字符串最前面设置为'-'号，并且索引加1
    }
    else unum=(unsigned)num;//若是num为正，直接赋值给unum

    //转换部分，注意转换后是逆序的
    do
    {
        str[i++]=index[unum%(unsigned)radix];//取unum的最后一位，并设置为str对应位，指示索引加1
        unum/=radix;//unum去掉最后一位

    }while(unum);//直至unum为0退出循环

    str[i]='\0';//在字符串最后添加'\0'字符，c语言字符串以'\0'结束。

    //将顺序调整过来
    if(str[0]=='-') k=1;//如果是负数，符号不用调整，从符号后面开始调整
    else k=0;//不是负数，全部都要调整

    char temp;//临时变量，交换两个值时用到
    for(j=k;j<=(i-1)/2;j++)//头尾一一对称交换，i其实就是字符串的长度，索引最大值比长度少1
    {
        temp=str[j];//头部赋值给临时变量
        str[j]=str[i-1+k-j];//尾部赋值给头部
        str[i-1+k-j]=temp;//将临时变量的值(其实就是之前的头部值)赋给尾部
    }

    return str;//返回转换后的字符串

}

